# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\user;.\APP;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\LED;.\APP\EXTI;.\APP\TIMER;.\APP\PWM;.\APP\USART;.\APP\key;.\APP\systick;.\APP\LED;.\APP\PRINTF;.\APP\AT24CXX;.\APP\MPU-6050;.\APP\EXTI;.\APP\CONTROL;.\APP\DataScope;.\APP\TIMER;.\APP\FILTER;.\APP\INIT;.\APP\NRF24L01;.\APP\sys;.\APP\spi;.\APP\OLED;.\APP\OLED_IIC;.\APP\SOUND;.\APP\ENCODER;.\APP\MOTOR;.\APP;.\Drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group stdperiph_Drive
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_adc.c
  group APP
    ./APP/MPU-6050/: mpu6050.c
    ./APP/systick/: systick.c
    ./APP/DataScope/: DataScope_DP.C
    ./APP/FILTER/: filter.c
    ./APP/EXTI/: exti.c
    ./APP/INIT/: init.c
    ./APP/key/: key.c
    ./APP/USART/: usart.c
    ./APP/NRF24L01/: nrf24l01.c
    ./APP/sys/: sys.c
    ./APP/OLED/: oled.c
    ./APP/LED/: led.c
    ./APP/SOUND/: sound.c
    ./APP/MOTOR/: motor.c
    ./APP/CONTROL/: control.c
    ./APP/ENCODER/: encoder.c
    ./APP/: ADC.c printf.c beep.c
  group Drive
    ./APP/spi/: spi.c
    ./APP/OLED_IIC/: iic_oled.c
    ./APP/MPU-6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Drive/: iic.c
